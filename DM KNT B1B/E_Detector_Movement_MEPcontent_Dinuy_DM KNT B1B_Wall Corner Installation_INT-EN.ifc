Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: 22c5a2ad-55cd-472c-bc2c-2d84b6d7d871, VersionGUID: 03f128a7-2b9a-4d8f-861a-2cb4a581d101, NumberOfSaves: 205]
File name: E_Detector_Movement_MEPcontent_Dinuy_DM KNT B1B_Wall Corner Installation_INT-EN.ifc
Time: 2026-08-27T14:57:18+02:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.3.40.26 (ENG) - IFC 24.3.40.26

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcBuildingElementProxy: E_Detector_Movement_MEPcontent_Dinuy_DM KNT B1B_Wall Corner Installation_INT-EN:DM KNT B1B, E_Detector_Movement_MEPcontent_Dinuy_DM KNT B1B_Wall Corner Installation_INT-EN:DM KNT B1B:1323402
In: F00
Type - Material: Color RGB 191-191-191, Color RGB 9002, Color RGB 080-080-080
Type - Other - Category: Security Devices; Family Name: E_Detector_Movement_MEPcontent_Dinuy_DM KNT B1B_Wall Corner Installation_INT-EN
Type - Model Properties - 3D Representation: 3DGeometry
Type - Constraints - Default Elevation: 0 mm
Type - Data - Detection Diameter (m): 12; Environmental Protection: IP55, Class II; Maximum Operating Temperature: 55 C; Mounting: Wall, ceiling or corner; Mounting Height (m): 2.5; Output Channels: 6+1
Type - Dimensions - Depth: 135 mm; Height: 80 mm; Rotation U-Axis Correction: 90 deg; Rotation V-Axis Correction: 45 deg; Rotation W-Axis Correction: 0 deg; Width: 80 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM_MC; Voltage: 32 V
Type - Identity Data - Article Description: 270º KNX Wall and ceiling mounted motion and presence detector white; Article Type: DM KNT B1B; Base Family Version: 26.09; Category: EL_SINGLEPOLESWITCH; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: 270º KNX Wall and ceiling mounted motion and presence detector white; EMCS Version: 5.0; ETIM Article Class: EC000133; Family Version: 26.09; GLN: 8422447000009; GTIN: 8422447018462; Manufacturer: Dinuy; Manufacturer Art. No.: DM KNT B1B; Manufacturer URL: https://dinuy.com/en/product/826/motion-presence-detector-270-wall-or-ceiling-mounting-white; MEPcontent Class: DETECTOR_MOVEMENT; Model: DM KNT B1B; OmniClass Number: 23.85.30.14.14; OmniClass Title: Movement/Vibration Detection; Product Line: Dinuy; Revit Version: 2024; Type Name: DM KNT B1B; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Body Color: Color RGB 9002
Type - Mechanical - Weight: 0.276 kg
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dinuy
Pset_BuildingElementProxyCommon - Reference: DM KNT B1B; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: DM KNT B1B
Other - Family: E_Detector_Movement_MEPcontent_Dinuy_DM KNT B1B_Wall Corner Installation_INT-EN; Family and Type: E_Detector_Movement_MEPcontent_Dinuy_DM KNT B1B_Wall Corner Installation_INT-EN: DM KNT B1B; FOD Visibility Safe1: no; FOD Visibilty Safe2: no; Insertion Point: 200 mm; Tilt Angle Safe: 90 deg; Type: DM KNT B1B; Type Id: 1323387
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 184.258 m2; FOD Diameter (mm): 12000 mm; FOD Height (mm): 2500 mm; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Tilt Angle: 90 deg; Volume: 0.000420999 m3
Identity Data - Function Code: E6311; Mark: 1
Phasing - Phase Created: 4. Plan over 10 years
Visibility - FOD Visibility: no; Wall Corner Inside Installation: no; Wall Corner Outside Installation: yes

# IfcDistributionPort, Port_1323402_1
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: CABLE; SystemType: SECURITY
